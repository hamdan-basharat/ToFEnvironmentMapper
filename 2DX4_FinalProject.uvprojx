# Keil uVision project 2DX4_FinalProject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2DX4_FinalProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ../Labs/2DX4_Lab8/2dx4_ds90-1/: PLL.c SysTick.c vl53l1_platform_2dx4.c VL53L1X_api.c onboardLEDs.c uart.c
    ./ToF Code/: ToF_Lidar.c
software components: CMSIS:CORE 5.3.0, Device:Startup 3.2.3
